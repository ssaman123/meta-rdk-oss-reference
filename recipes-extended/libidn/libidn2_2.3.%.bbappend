DEPENDS:remove = "libunistring"
PACKAGES := "${PN}"
